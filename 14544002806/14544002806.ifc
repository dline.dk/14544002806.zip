Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-08T13:27:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 08 13:27:45 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{51DF358E-9C46-49ED-89BC-8FA55B55AB20}\ifc * Database version: 5507 * Database creation date: Wed Nov 08 13:27:44 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 08 13:27:45 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 08 13:27:45 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: 8mm Head
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcWindow: dline_Hardware_WindowHandles_T16_SnapOnRose_cc43, 14544002806b:dline_Hardware_WindowHandles_T16_SnapOnRose_cc43:194037
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no
Type - Analytical Properties - Analytic Construction: <None>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Data - C-CDistance: 43; RoseType: Snap on
Type - General - Author: Gytautas Balevičius; BIMObjectName: dline_Hardware_WindowHandles_T16_SnapOnRose_cc43; DesignCountry: Denmark; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 08 75 00; MasterFormat2014Description: Window Hardware; NBSCertification: n/a; NBSDescription: Window latch and lock operating handles; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-60/395; NBSTypeID: n/a; OmniclassCode: 22-08 75 00; OmniclassDescription: Window Hardware; ProductFamily: Hardware; ProductGroup: Window handles; ProductInformation: http://dline.com/product/knud-holscher-collection-window-handle-t/?attribute_pa_material=satin-stainless-steel-aisi-316&attribute_pa_diameter=16&attribute_pa_item=snap-on-cover-30x65mm-cc-43-mm#; ProductionCountry: Lithuania; ProductSKU: 14544002806; Revision: n/a; Uniclass2015Code: Ss_25_38_20_95; Uniclass2015Title: Window hardware systems; Uniclass2015Version: Systems; UNSPSCCode: 31162801; Version: 1; Weight Net (kg): 0
Type - Identity Data - Description: T shaped window handle, on snap on rose; Manufacturer: info@dline.com; Type Mark: 19; Type Name: dline_Hardware_WindowHandles_T16_SnapOnRose_cc43
Type - Materials and Finishes - MainMaterial: AISI 316
Type - Other - Category: Windows; AccessibilityPerformance: n/a; AssetType: fixed; CodePerformance: n/a; Color: Steel; Constituents: 1x - T shaped window handle; 1x -Base rose; 1x - Snap on cover; DurationUnit: year; ExpectedLife: 20 years; Family Name: 14544002806b; Features: n/a; Finish: Satin; Grade: n/a; Material: AISI 316 stainless steel; ModelNumber: n/a; ModelReference: 45-25-60/395; Name: WindowHandles_T16_SnapOnRose_cc43; ReplacementCost: n/a; Shape: n/a; Size: 71 x 30 x 55 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
OverallHeight: 62 mm; OverallWidth: 22 mm
Pset_WindowCommon - Reference: n/a; IsExternal: no; FireRating: n/a; AcousticRating: n/a; SecurityRating: n/a; SmokeStop: no; GlazingAreaFraction: 0
Pset_ManufacturerTypeInformation - ModelReference: 45-25-60/395; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1
Dimensions - Area: 0.00518292 m2; Volume: 0.0000302787 m3
Identity Data - Mark: 6
Other - AssetIdentifier: n/a; BarCode: n/a; Family: 14544002806b: dline_Hardware_WindowHandles_T16_SnapOnRose_cc43; Family and Type: 14544002806b: dline_Hardware_WindowHandles_T16_SnapOnRose_cc43; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 14544002806b: dline_Hardware_WindowHandles_T16_SnapOnRose_cc43; Type Id: 14544002806b: dline_Hardware_WindowHandles_T16_SnapOnRose_cc43; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
